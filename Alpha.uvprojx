# Keil uVision project Alpha.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F405RGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.1.1
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 DSP CLOCK(12000000) ELITTLE
  output: Alpha +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32F40_41xxx USE_STDPERIPH_DRIVER HSE_VALUE=16000000
  c include: .\Hardware;.\Flight;.\User;.\Libraries\FatFS;.\Libraries\CMSIS\ST;.\Libraries\CMSIS\Core;.\Libraries\CMSIS\Startup;.\Libraries\CMSIS\System\inc;.\Libraries\CMSIS\System\src;.\Libraries\STM32F4xx_StdPeriph_Driver\inc;.\Libraries\STM32F4xx_StdPeriph_Driver\src
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Core
    ./Libraries/CMSIS/Core/: core_cm4.h
  group User
    ./User/: main.c
  group Hardware
    ./Hardware/: Buzzer.c GPS.c ICM_42688P.c QMC5883P.c TFCARD.c elrs.c ADC1in10.c Delay.c DSHOT.c USART3.c SW_I2C.c
  group System
    ./Libraries/CMSIS/System/src/: system_stm32f4xx.c
    ./Libraries/CMSIS/System/inc/: stm32f4xx_conf.h system_stm32f4xx.h
  group Startup
    ./Libraries/CMSIS/Startup/: startup_stm32f40_41xxx.s
  group Libraries
    ./Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_dma.c stm32f4xx_gpio.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_rcc.c stm32f4xx_spi.c stm32f4xx_tim.c stm32f4xx_usart.c
  group FatFS
    ./Libraries/FatFS/: diskio.c ff.c
  group Flght
    ./Flight/: attitude.c blackbox.c PID.c control.c protection.c navigation.c controller_angle.c controller_rate.c flight_controller.c
software components: CMSIS:CORE 6.1.1, Compiler:I/O:STDOUT 1.2.0, Device:CubeMX 1.0.0
